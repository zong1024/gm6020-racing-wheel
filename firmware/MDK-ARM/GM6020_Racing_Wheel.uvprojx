# Keil uVision project GM6020_Racing_Wheel.uvprojx, settings and files
target GM6020_Racing_Wheel (6160000::V6.16::ARMCLANG)
  device: STM32F427VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: GM6020_Racing_Wheel
  c flags: Optim=1
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ..\include;..\STM32CubeMX\Core\Inc;..\STM32CubeMX\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32CubeMX\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32CubeMX\Drivers\CMSIS\Include
  group Application
    ../src/: main.c pid.c gm6020.c wheel_app.c
  group Startup
    ../STM32CubeMX/MDK-ARM/: startup_stm32f427xx.s
  group CubeMX Core
    ../STM32CubeMX/Core/Src/: gpio.c can.c usart.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx HAL Driver
    ../STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c
